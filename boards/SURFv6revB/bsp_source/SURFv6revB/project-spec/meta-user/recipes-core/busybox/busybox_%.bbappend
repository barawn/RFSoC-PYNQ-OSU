SRC_URI += "file://user_2024-10-04-14-44-00.cfg"

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

